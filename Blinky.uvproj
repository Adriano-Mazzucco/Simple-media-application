# Keil uVision project Blinky.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: LED.c Blinky.c IRQ.c GLCD_SPI_LPC1700.c ADC.c KBD.c tower.c wham.c usbaudio.h usbcore.h usb.h usbhw.h type.h usbcfg.h usbuser.c usbhw.c usbdesc.c usbcore.c adcuser.c Turtle.c thomas.c frog.c frogger.c lefttruck.c righttruck.c pacman.c
